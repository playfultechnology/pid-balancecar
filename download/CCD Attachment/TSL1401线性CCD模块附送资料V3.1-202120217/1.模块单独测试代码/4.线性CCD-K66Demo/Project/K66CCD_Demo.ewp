# IAR project K66CCD_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\App; ..\Library; ..\System\Startup; ..\System\Startup\CMSIS; ..\User
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: K66_1.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\MK66xX1M_18.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 Freescale MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: src\User; src\Project_Setting\Libs; src\Project_Setting\Startup; src\Project_Setting\Linker; src\Drive
  OBJCOPY.OOCOutputFile: LQ_K66FX_LED.hex
  group App
    ../APP/: CCD.c CCD.h OLED.c OLED.h oled_font.h PIT.c PIT.h
  group Library
    ../Library/: common.h MK60_ADC.c MK60_ADC.h MK60_CMT.c MK60_CMT.h MK60_DMA.c MK60_DMA.h MK60_FLASH.c MK60_FLASH.h MK60_FTM.c MK60_FTM.h MK60_GPIO.c MK60_GPIO.h MK60_GPIO_Cfg.h MK60_IIC.c MK60_IIC.h MK60_LPTMR.c MK60_LPTMR.h MK60_PIT.c MK60_PIT.h MK60_PLL.c MK60_PLL.h MK60_SYSTICK.c MK60_SYSTICK.h MK60_UART.c MK60_UART.h MK60_WDOG.c MK60_WDOG.h
  group System/Startup
    ../System/Startup/: MK66F18.h start.c startup_MK66F18.s system_MK66F18.h
  group User
    ../USER/: control.c control.h include.h main.c show.c show.h
